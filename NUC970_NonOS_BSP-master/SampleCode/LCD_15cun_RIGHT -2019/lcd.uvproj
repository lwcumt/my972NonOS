# Keil uVision project lcd.uvproj, settings and files
target lcd (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: APP +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: LCD_TYPE =LCD_TYPE_15in     LCD_SIZE=LCDTYPE_15
  c misc: --gnu;
  c include: ..\..\Driver\Include;..\LCD_15cun_RIGHT;..\..\Driver\Include;..\..\ThirdParty\FATFS\src
  memory RVCT1: ROM 0x8000000 size 0x100000
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x80100000 size 0x400000
  memory RVCT9: RAM 0x100000 size 0x400000
  scatter file: ..\..\Script\nuc970.sct
  link misc: --entry 0x00000000
  group src
    ./: main.c pcf8563.c m25pe16.c spi_config.c uart_config.c comm.c chndot.c drv_glcd.c down_status.c download.c pic.c pic_exec.c word_lib.c file.c servo.c bmp.c nandflash.c timer.c port.c key.c tsc2046.c test_io.c name_input.c pinyin.c nand_config.c lcd_config.c process_main.c touch.c timer_config.c gtp.c i2c_config.c ff.c diskio.c sd_config.c SDGlue.c sdcopy.c gtp_touch.c keyboard.c code.c io.c comm_touch.c sysiotest.c modbus.c comm_plc.c
    ../../ThirdParty/FATFS/src/option/: cc936.c
  group Libraries
    ../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_nuc970.c startup_NUC970.s sys_nuc970.s lcd.c gpio.c i2c.c spi.c uart.c fmi.c etimer.c sdh.c
