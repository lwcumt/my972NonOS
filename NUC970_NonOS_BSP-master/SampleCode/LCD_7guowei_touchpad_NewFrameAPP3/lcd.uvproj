# Keil uVision project lcd.uvproj, settings and files
target lcd (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: APP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c misc: --gnu;
  c include: ..\..\Driver\Include;..\LCD_7guowei_touchpad_NewFrameAPP3;..\..\Driver\Source;..\..\ThirdParty\FATFS\src;.\cpGui;.\Form;.\mtpkey
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x100000 size 0x80000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\Script\nuc970.sct
  link misc: --entry 0
  group src
    ./: main.c io.c pcf8563.c m25pe16.c spi_config.c uart_config.c comm.c chndot.c drv_glcd.c down_status.c download.c pic.c pic_exec.c word_lib.c file.c servo.c bmp.c nandflash.c timer.c port.c key.c tsc2046.c test_io.c pinyin.c nand_config.c lcd_config.c process_main.c touch.c timer_config.c gtp.c i2c_config.c diskio.c sd_config.c SDGlue.c sdcopy.c gtp_touch.c comm_touch.c sysiotest.c name_input.c lcd_bright.c
    ../../ThirdParty/FATFS/src/option/: cc936.c
    ../../ThirdParty/FATFS/src/: ff.c
  group Libraries
    ../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_nuc970.c startup_NUC970.s sys_nuc970.s lcd.c gpio.c i2c.c spi.c uart.c etimer.c sdh.c mtp.c
  group cpGui
    ./cpGui/: datagui.c touchevent.c
  group Form
    ./Form/: mainform.c setupform.c waveform.c
  group Mtp
    ./mtpkey/: mtppass.c
