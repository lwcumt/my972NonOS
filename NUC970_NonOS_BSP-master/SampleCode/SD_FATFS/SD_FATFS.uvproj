# Keil uVision project SD_FATFS.uvproj, settings and files
target SD_FATFS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: sd_fatfs
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\Driver\Include;..\..\ThirdParty\FATFS\src
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\Script\nuc970.sct
  link misc: --entry 0
  group User
    ./: main.c diskio.c SDGlue.c
  group Libraries
    ../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_nuc970.c startup_NUC970.s sys_nuc970.s sys_ebi.c sdh.c gpio.c
  group FATFS
    ../../ThirdParty/FATFS/src/: ff.c
    ../../ThirdParty/FATFS/src/option/: cc936.c
