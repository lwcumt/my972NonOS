# Keil uVision project lcd.uvproj, settings and files
target lcd (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: lcd +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c misc: --gnu
  c include: ..\..\Driver\Include;..\LCD_Boot;..\..\Driver\Include;..\..\ThirdParty\FATFS\src
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x100000 size 0x80000
  memory RVCT9: RAM 0x3c000000 size 0xe000
  scatter file: .\config\nuc970.sct
  link misc: --entry 0x00100000
  group src
    ./: main.c drv_glcd.c file.c nandflash.c nand_config.c lcd_config.c io.c chndot.c uart_config.c
  group Libraries
    ../../Driver/Source/: standalone.c sys.c sys_timer.c sys_uart.c system_nuc970.c startup_NUC970.s sys_nuc970.s lcd.c gpio.c i2c.c spi.c fmi.c etimer.c uart.c
